Commit message: clean

File: urdf/base.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- added link base_link; visual cylinder length=0.6 radius=0.35
